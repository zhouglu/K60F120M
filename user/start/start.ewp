# IAR project start.ewp, settings and files
configuration Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../lib/K60F120M.iar/debug/psp; ../..lib/K60F120M.iar/debug/bsp/Sources; ../../lib/K60F120M.iar/debug/bsp/Generated_Code; ../../lib/K60F120M.iar/debug/bsp; ../../lib/K60F120M.iar/debug/shell; ../../lib/K60F120M.iar/debug
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: start.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../lib/K60F120M.iar/debug/bsp/ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: ../../lib/K60F120M.iar/debug/bsp/intflash.icf
configuration Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../lib/K60F120M.iar/release/psp; ../../lib/K60F120M.iar/release/bsp/Sources; ../../lib/K60F120M.iar/release/bsp/Generated_Code; ../../lib/K60F120M.iar/release/bsp; ../../lib/K60F120M.iar/release/shell; ../../lib/K60F120M.iar/release
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: ../../lib/K60F120M.iar/release/bsp/ram.icf
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../lib/K60F120M.iar/release/bsp/intflash.icf
  group MQX Libraries
    ../../lib/K60F120M.iar/debug/bsp/: bsp.a
    ../../lib/K60F120M.iar/release/bsp/: bsp.a
    ../../lib/K60F120M.iar/debug/psp/: psp.a
    ../../lib/K60F120M.iar/release/psp/: psp.a
    ../../lib/K60F120M.iar/debug/shell/: shell.a
    ../../lib/K60F120M.iar/release/shell/: shell.a
  group Source
    src/: main.c
  group Source/Analog Sample
    src/AnalogSample/: as_main.c calc_freq.c fft_2.c
