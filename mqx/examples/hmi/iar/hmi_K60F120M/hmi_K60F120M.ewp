# IAR project hmi_K60F120M.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../lib/K60F120M.iar/debug/shell; ../../../../../lib/K60F120M.iar/debug/psp; ../../../../../lib/K60F120M.iar/debug/bsp/tss; ../../../../../lib/K60F120M.iar/debug/bsp/Sources; ../../../../../lib/K60F120M.iar/debug/bsp/Generated_Code; ../../../../../lib/K60F120M.iar/debug/bsp; ../../../../../lib/K60F120M.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../../../../lib/twrk70f120m.iar/debug/shell; ../../../../../lib/twrk70f120m.iar/debug/psp; ../../../../../lib/twrk70f120m.iar/debug/bsp/tss; ../../../../../lib/twrk70f120m.iar/debug/bsp/Sources; ../../../../../lib/twrk70f120m.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk70f120m.iar/debug/bsp; ../../../../../lib/twrk70f120m.iar/debug
  OBJCOPY.OOCOutputFile: hmi_K60F120M.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../../../../lib/K60F120M.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../lib/K60F120M.iar/release/shell; ../../../../../lib/K60F120M.iar/release/psp; ../../../../../lib/K60F120M.iar/release/bsp/tss; ../../../../../lib/K60F120M.iar/release/bsp/Sources; ../../../../../lib/K60F120M.iar/release/bsp/Generated_Code; ../../../../../lib/K60F120M.iar/release/bsp; ../../../../../lib/K60F120M.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../../../../../lib/twrk70f120m.iar/release/shell; ../../../../../lib/twrk70f120m.iar/release/psp; ../../../../../lib/twrk70f120m.iar/release/bsp/tss; ../../../../../lib/twrk70f120m.iar/release/bsp/Sources; ../../../../../lib/twrk70f120m.iar/release/bsp/Generated_Code; ../../../../../lib/twrk70f120m.iar/release/bsp; ../../../../../lib/twrk70f120m.iar/release
  ILINK.IlinkIcfFile: ../../../../../lib/K60F120M.iar/release/bsp/intflash.icf
  group MQX Libraries
    ../../../../../lib/K60F120M.iar/release/bsp/: bsp.a tss.a
    ../../../../../lib/K60F120M.iar/debug/bsp/: bsp.a tss.a
    ../../../../../lib/K60F120M.iar/debug/psp/: psp.a
    ../../../../../lib/K60F120M.iar/release/psp/: psp.a
    ../../../../../lib/K60F120M.iar/debug/shell/: shell.a
    ../../../../../lib/K60F120M.iar/release/shell/: shell.a
  group Source
    ../../: hmi.c
